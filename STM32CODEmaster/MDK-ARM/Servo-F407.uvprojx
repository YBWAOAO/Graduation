# Keil uVision project Servo-F407.uvprojx, settings and files
target Servo-F407 (6140000::V6.14::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Servo-F407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;                                                     ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                     ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                     ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                     ../Drivers/CMSIS/Include;                                                     ..\HARDWARE\motor;                                                     ..\HARDWARE\MLX90614;                                                     ..\HARDWARE\Linefinder;                                                     ..\HARDWARE\control;                                                     ..\HARDWARE\uart;                                                     ..\HARDWARE\VL53L0X\core;                                                     ..\HARDWARE\VL53L0X\platform;                                                     ..\HARDWARE\BPSim;                                                     ..\HARDWARE\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Systeam
    ../Systeam/delay/: delay.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Hardware
    ../HARDWARE/MLX90614/: mlx90614.c
    ../HARDWARE/control/: control.c
    ../HARDWARE/uart/: uart_handler.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 5.4.0
